# Keil uVision project YH_ByDevil.uvprojx, settings and files
target STM32 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: YH_ByDevil +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\Source\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Source\Libraries\CMSIS\CM3\CoreSupport;.\Source\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\Source\YH_Clib;.\Source\System;.\Source\RFID;.\Source\STM32_delay;.\Source\STM32_UART;.\Source\esp;.\Source\MsgManage
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xd000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StartUp
    ./Source/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group CMSIS
    ./Source/Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./Source/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group STM32_Lib_V3.5
    ./Source/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group System
    ./Source/System/: main.c stm32f10x_it.c allinclude.h LogicRun.c Button_Read.c
    ./Source/MsgManage/: MsgManage.c
  group RFID
    ./Source/RFID/: rc522.c
  group YH_Clib
    ./Source/YH_Clib/: YH_Clibrary.c YH_Queue.c
  group STM32_USART
    ./Source/STM32_UART/: STM32_UART3.c STM32_UART2.c STM32_UART1.c
  group STM32_delay
    ./Source/STM32_delay/: STM32_delay.c
  group esp
    ./Source/esp/: Esp8266.c
software components: CMSIS:CORE 5.0.1
