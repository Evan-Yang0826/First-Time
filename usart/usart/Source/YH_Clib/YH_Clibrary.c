/****************************************Copyright (c)******************************************
**
**                懿航工作室   Copyright(C) 2011, Yehhon ,All rights reserved.
**
**-------------------------------------文件信息--------------------------------------------
  **  文 件 名:    YH_Clibrary.C 
  **  描    述:    通用函数库
  **  创 建 人:    Devil
**--------------------------------------------------------------------------------------------
  **  修改历史:
  **  2011/09/28   Devil   建立 
************************************************************************************************/
#include "../YH_CLib/YH_Type.h"
#define  YH_CLIB_LOCAL 
#include "YH_Clibrary.h"
/*************************************************************************************************
** 函数名称:    YHMemoryCopy
** 功能描述: 	存储器拷贝，不检查0值
** 输　  入:    无
** 输　  出:    无     
** 返 回 值:    无
** 先决条件: 
** 全局变量: 
** 调用模块: 
**--------------------------------------------------------------------------------------------
** 修改记录:
** 2011/09/19   Devil   建立  
*************************************************************************************************/
void YHMemoryCopy(INT8U *source, INT8U *dest, INT32U copylong)
{
	INT32U i;

	for(i=0;i<copylong;i++)
	{
		dest[i]=source[i];
	}
}
/*************************************************************************************************
** 函数名称:    YHMemoryCmp
** 功能描述: 	比较指定长度的内存数据
** 输　  入:    无
** 输　  出:    无     
** 返 回 值:    TRUE 数据相同 FLASE 数据有不同位
** 先决条件: 
** 全局变量: 
** 调用模块: 
**--------------------------------------------------------------------------------------------
** 修改记录:
** 2011/09/19   Devil   建立  
*************************************************************************************************/
INT8U YHMemoryCmp(INT8U *source, INT8U *dest, INT32U cmplong)
{
	INT32U i;

	for(i=0;i<cmplong;i++)
	{
		if(dest[i]!=source[i])
		{
			return FALSE;
		}
	}
	return TRUE;
}
/*************************************************************************************************
** 函数名称:    YHMemoryCmp
** 功能描述: 	比较指定长度的内存数据
** 输　  入:    无
** 输　  出:    无     
** 返 回 值:    TRUE 数据相同 FLASE 数据有不同位
** 先决条件: 
** 全局变量: 
** 调用模块: 
**--------------------------------------------------------------------------------------------
** 修改记录:
** 2011/09/19   Devil   建立  
*************************************************************************************************/
INT8U YHMemoryClear(INT8U *dest, INT32U clplong)
{
	INT32U i;

	for(i=0;i<clplong;i++)
	{
		dest[i]=0;	
	}
	return TRUE;
}
/*************************************************************************************************
**					　　　　　        END FILE
**************************************************************************************************/
